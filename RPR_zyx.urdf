Commit message: Fixed dynamic model, introduced time dependency

File: RPR_zyx.urdf (robot description, URDF)
Before this commit: robot RPR, 5 links, 4 joints
Links:
- link Link2: mass 0 -> 1.1919
- link Link3: mass 0 -> 0.7317
- link Link4: mass 0 -> 0.8173
